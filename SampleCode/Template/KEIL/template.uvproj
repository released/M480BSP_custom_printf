# Keil uVision project template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __WINS__ OPT_SPEED,
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\ThirdParty\libmad\inc;..\..\..\Library\StdDriver\inc;..\..\..\Library\UsbHostLib\INCLUDE;..\..\..\Library\UsbHostLib\INCLUDE\inc_mass;..\..\..\ThirdParty\FATFS\source
  asm define: Stack_Size=0x2000 Heap_Size=0x2000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\obj\template.sct
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Source
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: sys.c clk.c uart.c retarget.c gpio.c timer.c
